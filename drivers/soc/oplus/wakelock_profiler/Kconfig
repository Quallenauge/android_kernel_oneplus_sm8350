## drivers/soc/oplus/wakelock_profiler/Kconfig
```kconfig
config OPLUS_WAKELOCK_PROFILER
bool "config oplus wakelock profiler"
help
    Select this config to enable oplus wakelock profiler
```
